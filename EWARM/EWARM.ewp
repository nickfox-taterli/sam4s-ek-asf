# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4S16C__; UDD_ENABLE
  ICCARM.CCDiagSuppress: Pa089,Pe188,Pa091,Pe236
  ICCARM.CCIncludePath2: ..\applications\include; ..\xdk-asf\common\services\clock; ..\xdk-asf\common\services\delay; ..\xdk-asf\common\services\delay\sam; ..\xdk-asf\common\services\gpio; ..\xdk-asf\common\services\gpio\sam_gpio; ..\xdk-asf\common\services\ioport; ..\xdk-asf\common\services\ioport\sam; ..\xdk-asf\common\services\serial; ..\xdk-asf\common\services\serial\sam_uart; ..\xdk-asf\common\services\sleepmgr; ..\xdk-asf\common\services\sleepmgr\sam; ..\xdk-asf\common\services\spi; ..\xdk-asf\common\services\spi\sam_spi; ..\xdk-asf\common\services\storage\ctrl_access; ..\xdk-asf\common\services\storage\ecc_hamming; ..\xdk-asf\common\services\usb; ..\xdk-asf\common\services\usb\class\cdc; ..\xdk-asf\common\services\usb\class\cdc\device; ..\xdk-asf\common\services\usb\class\composite\device; ..\xdk-asf\common\services\usb\class\dfu_flip; ..\xdk-asf\common\services\usb\class\dfu_flip\device; ..\xdk-asf\common\services\usb\class\hid; ..\xdk-asf\common\services\usb\class\hid\device; ..\xdk-asf\common\services\usb\class\hid\device\generic; ..\xdk-asf\common\services\usb\class\hid\device\kbd; ..\xdk-asf\common\services\usb\class\hid\device\mouse; ..\xdk-asf\common\services\usb\class\hid\device\mtouch; ..\xdk-asf\common\services\usb\class\msc; ..\xdk-asf\common\services\usb\class\msc\device; ..\xdk-asf\common\services\usb\class\phdc; ..\xdk-asf\common\services\usb\class\phdc\device; ..\xdk-asf\common\services\usb\class\vendor; ..\xdk-asf\common\services\usb\class\vendor\device; ..\xdk-asf\common\services\usb\udc; ..\xdk-asf\common\boards; ..\xdk-asf\common\utils; ..\xdk-asf\common\utils\interrupt; ..\xdk-asf\common\utils\stdio\stdio_serial; ..\xdk-asf\sam\drivers\acc; ..\xdk-asf\sam\drivers\adc; ..\xdk-asf\sam\drivers\chipid; ..\xdk-asf\sam\drivers\crccu; ..\xdk-asf\sam\drivers\dacc; ..\xdk-asf\sam\drivers\ebi\smc; ..\xdk-asf\sam\drivers\efc; ..\xdk-asf\sam\drivers\hsmci; ..\xdk-asf\sam\drivers\matrix; ..\xdk-asf\sam\drivers\pdc; ..\xdk-asf\sam\drivers\pio; ..\xdk-asf\sam\drivers\pmc; ..\xdk-asf\sam\drivers\pwm; ..\xdk-asf\sam\drivers\rstc; ..\xdk-asf\sam\drivers\rtc; ..\xdk-asf\sam\drivers\rtt; ..\xdk-asf\sam\drivers\spi; ..\xdk-asf\sam\drivers\ssc; ..\xdk-asf\sam\drivers\tc; ..\xdk-asf\sam\drivers\twi; ..\xdk-asf\sam\drivers\uart; ..\xdk-asf\sam\drivers\udp; ..\xdk-asf\sam\drivers\usart; ..\xdk-asf\sam\drivers\wdt; ..\xdk-asf\sam\components\sd_mmc; ..\xdk-asf\sam\components\display\aat31xx; ..\xdk-asf\sam\components\display\ili9325; ..\xdk-asf\sam\components\memory\nand_flash\nand_flash_ebi; ..\xdk-asf\sam\components\memory\nand_flash\nand_flash_ebi\ftl_lib; ..\xdk-asf\sam\components\resistive_touch\ads7843; ..\xdk-asf\sam\services\flash_efc; ..\xdk-asf\sam\services\resistive_touch; ..\xdk-asf\sam\utils; ..\xdk-asf\sam\utils\cmsis\sam4s\include; ..\xdk-asf\sam\utils\cmsis\sam4s\include\component; ..\xdk-asf\sam\utils\cmsis\sam4s\include\instance; ..\xdk-asf\sam\utils\cmsis\sam4s\include\pio; ..\xdk-asf\sam\utils\header_files; ..\xdk-asf\sam\utils\preprocessor; ..\thirdparty\Fatfs\fatfs\src\source; ..\thirdparty\FreeRTOS\Source\include; ..\thirdparty\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\thirdparty\lvgl; ..\thirdparty\lvgl\demos; ..\thirdparty\lvgl\porting; ..\thirdparty\lvgl\src; ..\thirdparty\qtouch\generic\include; ..\thirdparty\qtouch\generic\sam\qtouch\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: ..\applications\include; ..\thirdparty\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: EWARM.hec
  ILINK.IlinkOutputFile: ewarm.out
  ILINK.IlinkIcfFile: ../xdk-asf/sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../xdk-asf/sam/utils/header_files; ../xdk-asf/common/services/spi/sam_spi; ../xdk-asf/sam/utils/preprocessor; ../xdk-asf/sam/drivers/pio; ../..; ../xdk-asf/sam/utils/cmsis/sam4s/include; ../xdk-asf/sam/drivers/ebi/smc; ../xdk-asf/common/services/serial; ../xdk-asf/sam/drivers/spi; ../xdk-asf/common/utils; ../xdk-asf/sam/boards/sam4s_ek; ../xdk-asf/sam/components/resistive_touch/ads7843; ../xdk-asf/common/services/clock; ../xdk-asf/sam/boards; ../xdk-asf/sam/components/display/aat31xx; ../xdk-asf/common/utils/stdio/stdio_serial; ..; ../xdk-asf/common/services/gpio; ../xdk-asf/sam/utils/cmsis/sam4s/source/templates; ../xdk-asf/sam/drivers/uart; ../xdk-asf/sam/utils; ../xdk-asf/sam/drivers/usart; ../xdk-asf/common/services/serial/sam_uart; ../xdk-asf/common/boards; ../../..; ../xdk-asf/sam/components/display/ili9325; ../xdk-asf/common/services/ioport; ../xdk-asf/sam/drivers/pmc; ../xdk-asf/common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  group applications
    ../applications/source/: init.c main.c
  group common/services/clock/sam4s
    ../xdk-asf/common/services/clock/sam4s/: sysclk.c
  group common/services/delay
    ../xdk-asf/common/services/delay/sam/: cycle_counter.c
  group common/services/ioport
    ../xdk-asf/common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../xdk-asf/common/services/ioport/sam/: ioport_pio.h
  group common/services/serial
    ../xdk-asf/common/services/serial/: usart_serial.c
  group common/services/sleepmgr
    ../xdk-asf/common/services/sleepmgr/sam/: sleepmgr.c
  group common/services/spi/sam_spi
    ../xdk-asf/common/services/spi/sam_spi/: spi_master.c
  group common/services/storage/ctrl_access
    ../xdk-asf/common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../xdk-asf/common/services/storage/ecc_hamming/: ecc-sw.c
  group common/services/usb/class/cdc/device
    ../xdk-asf/common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/class/composite/device
    ../xdk-asf/common/services/usb/class/composite/device/: udi_composite_desc.c
  group common/services/usb/class/dfu_flip/device
    ../xdk-asf/common/services/usb/class/dfu_flip/device/: udi_dfu_atmel.c udi_dfu_atmel_desc.c
  group common/services/usb/class/hid/device
    ../xdk-asf/common/services/usb/class/hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../xdk-asf/common/services/usb/class/hid/device/generic/: udi_hid_generic.c udi_hid_generic_desc.c
  group common/services/usb/class/hid/device/kbd
    ../xdk-asf/common/services/usb/class/hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/mouse
    ../xdk-asf/common/services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/usb/class/hid/device/mtouch
    ../xdk-asf/common/services/usb/class/hid/device/mtouch/: udi_hid_multitouch.c udi_hid_multitouch_desc.c
  group common/services/usb/class/msc/device
    ../xdk-asf/common/services/usb/class/msc/device/: udi_msc.c udi_msc_desc.c
  group common/services/usb/class/phdc/device
    ../xdk-asf/common/services/usb/class/phdc/device/: udi_phdc.c udi_phdc_desc.c
  group common/services/usb/class/vendor/device
    ../xdk-asf/common/services/usb/class/vendor/device/: udi_vendor.c udi_vendor_desc.c
  group common/services/usb/udc
    ../xdk-asf/common/services/usb/udc/: udc.c udc_dfu_small.c
  group common/utils/interrupt
    ../xdk-asf/common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../xdk-asf/common/utils/stdio/: read.c write.c
  group sam/components/display/aat31xx
    ../xdk-asf/sam/components/display/aat31xx/: aat31xx.c
  group sam/components/display/ili9325
    ../xdk-asf/sam/components/display/ili9325/: ili9325.c
  group sam/components/memory/nand_flash/nand_flash_ebi
    ../xdk-asf/sam/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_model.c nand_flash_raw_smc.c nand_flash_spare_scheme.c
  group sam/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../xdk-asf/sam/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
    ../xdk-asf/sam/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c
  group sam/components/resistive_touch/ads7843
    ../xdk-asf/sam/components/resistive_touch/ads7843/: ads7843.c
  group sam/components/sd_mmc
    ../xdk-asf/sam/components/sd_mmc/: sd_mmc.c sd_mmc_mem.c
  group sam/drivers/acc
    ../xdk-asf/sam/drivers/acc/: acc.c
  group sam/drivers/adc
    ../xdk-asf/sam/drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/chipid
    ../xdk-asf/sam/drivers/chipid/: chipid.c
  group sam/drivers/crccu
    ../xdk-asf/sam/drivers/crccu/: crccu.c
  group sam/drivers/dacc
    ../xdk-asf/sam/drivers/dacc/: dacc.c
  group sam/drivers/ebi/smc
    ../xdk-asf/sam/drivers/ebi/smc/: smc.c
  group sam/drivers/efc
    ../xdk-asf/sam/drivers/efc/: efc.c
  group sam/drivers/hsmci
    ../xdk-asf/sam/drivers/hsmci/: hsmci.c
  group sam/drivers/matrix
    ../xdk-asf/sam/drivers/matrix/: matrix.c
  group sam/drivers/pdc
    ../xdk-asf/sam/drivers/pdc/: pdc.c
  group sam/drivers/pio
    ../xdk-asf/sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../xdk-asf/sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pwm
    ../xdk-asf/sam/drivers/pwm/: pwm.c
  group sam/drivers/rstc
    ../xdk-asf/sam/drivers/rstc/: rstc.c
  group sam/drivers/rtc
    ../xdk-asf/sam/drivers/rtc/: rtc.c
  group sam/drivers/rtt
    ../xdk-asf/sam/drivers/rtt/: rtt.c
  group sam/drivers/spi
    ../xdk-asf/sam/drivers/spi/: spi.c
  group sam/drivers/ssc
    ../xdk-asf/sam/drivers/ssc/: ssc.c
  group sam/drivers/tc
    ../xdk-asf/sam/drivers/tc/: tc.c
  group sam/drivers/twi
    ../xdk-asf/sam/drivers/twi/: twi.c
  group sam/drivers/uart
    ../xdk-asf/sam/drivers/uart/: uart.c
  group sam/drivers/udp
    ../xdk-asf/sam/drivers/udp/: udp_device.c
  group sam/drivers/usart
    ../xdk-asf/sam/drivers/usart/: usart.c
  group sam/drivers/wdt
    ../xdk-asf/sam/drivers/wdt/: wdt.c
  group sam/services/flash_efc
    ../xdk-asf/sam/services/flash_efc/: flash_efc.c
  group sam/services/resistive_touch
    ../xdk-asf/sam/services/resistive_touch/: rtouch.c
  group sam/utils/cmsis/sam4s/source/templates
    ../xdk-asf/sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../xdk-asf/sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group thirdparty/Fatfs
    ../thirdparty/Fatfs/fatfs/src/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group thirdparty/FreeRTOS
    ../thirdparty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group thirdparty/FreeRTOS/portable
    ../thirdparty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../thirdparty/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group thirdparty/LVGL/core
    ../thirdparty/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group thirdparty/LVGL/demo/benchmark
    ../thirdparty/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../thirdparty/lvgl/demos/benchmark/: lv_demo_benchmark.c
  group thirdparty/LVGL/demo/keypad_encoder
    ../thirdparty/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group thirdparty/LVGL/demo/music
    ../thirdparty/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../thirdparty/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group thirdparty/LVGL/demo/stress
    ../thirdparty/lvgl/demos/stress/: lv_demo_stress.c
    ../thirdparty/lvgl/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group thirdparty/LVGL/demo/widgets
    ../thirdparty/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../thirdparty/lvgl/demos/widgets/: lv_demo_widgets.c
  group thirdparty/LVGL/draw
    ../thirdparty/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group thirdparty/LVGL/draw/sw
    ../thirdparty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group thirdparty/LVGL/extra
    ../thirdparty/lvgl/src/extra/: lv_extra.c
  group thirdparty/LVGL/extra/layouts
    ../thirdparty/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../thirdparty/lvgl/src/extra/layouts/grid/: lv_grid.c
  group thirdparty/LVGL/extra/themes
    ../thirdparty/lvgl/src/extra/themes/default/: lv_theme_default.c
  group thirdparty/LVGL/extra/widgets
    ../thirdparty/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../thirdparty/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../thirdparty/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../thirdparty/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../thirdparty/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../thirdparty/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../thirdparty/lvgl/src/extra/widgets/led/: lv_led.c
    ../thirdparty/lvgl/src/extra/widgets/list/: lv_list.c
    ../thirdparty/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../thirdparty/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../thirdparty/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../thirdparty/lvgl/src/extra/widgets/span/: lv_span.c
    ../thirdparty/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../thirdparty/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../thirdparty/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../thirdparty/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../thirdparty/lvgl/src/extra/widgets/win/: lv_win.c
  group thirdparty/LVGL/font
    ../thirdparty/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group thirdparty/LVGL/hal
    ../thirdparty/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group thirdparty/LVGL/misc
    ../thirdparty/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group thirdparty/LVGL/port
    ../thirdparty/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group thirdparty/LVGL/widgets
    ../thirdparty/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group thirdparty/qtouch
    ../thirdparty/qtouch/generic/sam/qtouch/lib/iar/: libsam4s-32qt-k-8rs-iar.a
