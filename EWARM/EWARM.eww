<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\EWARM.ewp</path>
	</project>
</workspace>
