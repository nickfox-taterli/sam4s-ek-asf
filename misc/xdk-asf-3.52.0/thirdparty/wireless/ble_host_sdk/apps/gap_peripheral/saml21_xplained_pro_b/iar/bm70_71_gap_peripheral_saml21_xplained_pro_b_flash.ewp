# IAR project bm70_71_gap_peripheral_saml21_xplained_pro_b_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; HOST_MCU_DEVICE=HOST_MCU_SAML21; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAML21J18B__; BNO_SENSOR_SERVICE; I2C_MASTER_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../services/sensor/bno055; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0; ../../../../services/serial_fifo; ../../../../ble_services/sensor_service; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../../../../common2/services/delay; ../../../../../../../sam0/utils; ../../../../utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../inc; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../sam0/utils/cmsis/saml21/include_b; ../../../../../../../sam0/drivers/sercom/i2c; ../../../../services/console; ../../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../../common/utils; ../../../../services/serial/uart; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../config/saml21; ../../../../../../../sam0/drivers/tc; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../common2/services/delay/sam0; ../..; ../../../../services/timer; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../common/services/ioport; ../../../../../../../sam0/drivers/extint; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/clock; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../ble_services/ble_mgr; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bm70_71_gap_peripheral_saml21_xplained_pro_b_flash.bin
  ILINK.IlinkOutputFile: bm70_71_gap_peripheral_saml21_xplained_pro_b_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e15b.h saml21j17b.h saml21j18b.h saml21g18b.h saml21e18b.h saml21g16b.h saml21j16b.h saml21.h saml21g17b.h saml21e16b.h saml21e17b.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21g18b.h saml21e16b.h saml21j17b.h saml21e15b.h saml21e17b.h saml21g16b.h saml21e18b.h saml21j16b.h saml21g17b.h saml21j18b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: gclk.h rtc.h tcc1.h oscctrl.h sercom0.h dmac.h sercom3.h eic.h mtb.h osc32kctrl.h pac.h tc1.h usb.h sercom4.h tc3.h rstc.h trng.h sercom5.h tcc0.h sercom2.h ac.h tc0.h port.h pm.h ccl.h tc4.h wdt.h tal.h dsu.h tc2.h supc.h tcc2.h evsys.h dac.h opamp.h sercom1.h adc.h nvmctrl.h aes.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/component/: opamp.h pm.h sercom.h oscctrl.h port.h wdt.h mtb.h pac.h dsu.h dac.h mclk.h adc.h usb.h osc32kctrl.h tal.h dmac.h supc.h trng.h gclk.h evsys.h rstc.h rtc.h ac.h aes.h ccl.h tc.h tcc.h eic.h nvmctrl.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h stringz.h tpaste.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom.h sercom_pinout.h sercom_interrupt.h
  group sam0/drivers/sercom/i2c
    ../../../../../../../sam0/drivers/sercom/i2c/: i2c_master.h i2c_common.h i2c_master_interrupt.h
  group sam0/drivers/sercom/i2c/i2c_sam0
    ../../../../../../../sam0/drivers/sercom/i2c/i2c_sam0/: i2c_master_interrupt.c i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../../sam0/drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/i2c/quick_start_master_callback/: qs_i2c_master_callback.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../../sam0/drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group thirdparty/wireless/ble_host_sdk/src
    ../../../../src/: event_mem.c fifo.c bm_application_mode.c platform.c ble_api.c bm_program_mode.c interface.c dfu_api.c memory.c
  group thirdparty/wireless/ble_host_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_host_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_host_sdk/services/timer/sam0
    ../../../../services/timer/sam0/: timer_hw.c
  group thirdparty/wireless/ble_host_sdk/services/sensor/bno055
    ../../../../services/sensor/bno055/: bno055_port.h bno055.h bno055_doc.h
  group thirdparty/wireless/ble_host_sdk/services/sensor/bno055/sam0
    ../../../../services/sensor/bno055/sam0/: bno055.c bno055_port.c
  group thirdparty/wireless/ble_host_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_host_sdk/services/serial/uart/sam0
    ../../../../services/serial/uart/sam0/: serial_drv.c
  group thirdparty/wireless/ble_host_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_host_sdk/services/console/sam0
    ../../../../services/console/sam0/: console_serial.c
  group thirdparty/wireless/ble_host_sdk/utils
    ../../../../utils/: bm_utils.c bm_utils.h ble_utils.h
  group thirdparty/wireless/ble_host_sdk/ble_services/sensor_service
    ../../../../ble_services/sensor_service/: acc_gyro_sensor_service.c acc_gyro_sensor_service.h
  group thirdparty/wireless/ble_host_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_host_sdk/apps/gap_peripheral
    ../../: peripheral_app.c peripheral_app.h
  group thirdparty/wireless/ble_host_sdk/apps/gap_peripheral/saml21_xplained_pro_b/iar
    ./: asf.h
  group thirdparty/wireless/ble_host_sdk/apps/config/saml21
    ../../../config/saml21/: conf_extint.h conf_timer.h conf_bno055.h conf_board.h conf_console.h conf_serialdrv.h conf_clocks.h conf_gpio.h
  group thirdparty/wireless/ble_host_sdk/inc
    ../../../../inc/: platform.h memory.h ble_api.h interface.h fifo.h bm_mode.h platform_files.h config.h bm_program_mode.h dfu_api.h bm_application_mode.h event_mem.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam0
    ../../../../../../../common/services/ioport/sam0/: ioport.h
  group common/boards
    ../../../../../../../common/boards/: board.h
